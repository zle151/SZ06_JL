# Keil uVision project GD32F407.uvprojx, settings and files
target BUSINESS_1 EC11 (6190000::V6.19::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407 +hex
  AfterMake: ./keil5_disp_size_bar.exe
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: BUSINESS=1
  c misc: -Wno-invalid-source-encoding
  c include: ..\User;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\CMSIS;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Library;..\Library\SPI;..\Library\I2C;..\Library\USART;..\Library\ADC;..\Hardware;..\Hardware\I2C_OLED;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../Hardware/: board_config.h
    ../App/: App.h App_Input.c App_Display.c App_Test.c App_Password.c
  group User
    ../User/: gd32f4xx_it.c main.c systick.c tasks_timer.c tasks.c tasks_1.c tasks_2.c tasks_3.c tasks_4.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_gpio.c gd32f4xx_usart.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_dma.c gd32f4xx_pmu.c gd32f4xx_rtc.c gd32f4xx_fwdgt.c gd32f4xx_wwdgt.c gd32f4xx_i2c.c gd32f4xx_spi.c gd32f4xx_adc.c
  group Library
    ../Library/: EXTI.c TIMER.c
    ../Library/USART/: USART0.c USART.c
  group Library/configs
    ../Library/SPI/: SPI_config.h
    ../Library/USART/: USART_config.h
    ../Library/: EXTI_config.h TIMER_config.h
    ../Library/I2C/: I2C_config.h
    ../Library/ADC/: ADC_config.h
  group Library/I2C
    ../Library/I2C/: I2C.c I2C0.c I2C2.c
  group Library/ADC
    ../Library/ADC/: ADC.c ADC0.c
  group Library/SPI
    ../Library/SPI/: SPI1.c SPI0.c SPI.c
  group Hardware
    ../Hardware/: bsp_adcurrent.c bsp_adkey.c bsp_advoltage.c bsp_dot_matrix.c bsp_ec11.c bsp_led_188.c bsp_touch_key.c bsp_ws2812.c
    ../Hardware/I2C_OLED/: oled.c
  group Doc
    ../Doc/: readme.txt
target BUSINESS_2 ADKey (6210000::V6.21::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: as above
  output: GD32F407 +hex
  AfterMake: ./keil5_disp_size_bar.exe
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: BUSINESS=2
  c misc: -Wno-invalid-source-encoding
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target BUSINESS_3 Lock (6210000::V6.21::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: as above
  output: GD32F407 +hex
  AfterMake: ./keil5_disp_size_bar.exe
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: BUSINESS=3
  c misc: -Wno-invalid-source-encoding
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target BUSINESS_4 DotMatrix (6210000::V6.21::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: as above
  output: GD32F407 +hex
  AfterMake: ./keil5_disp_size_bar.exe
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: BUSINESS=4
  c misc: -Wno-invalid-source-encoding
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
